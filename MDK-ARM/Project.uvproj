# Keil uVision project Project.uvproj, settings and files
target stm32_template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32_template +hex
  AfterMake: C:\Program Files (x86)\STMicroelectronics\Software\Flash Loader Demonstrator\STMFlashLoader.exe -c --pn 30 --br 115200 -i STM32_High-density_512K -e --all -p --dwp --drp -d --a 8000000 --fn .\@H.hex
  c flags: Optim=4 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: ..\;C:\stm32\stm32f10x_std\inc;C:\stm32\ustrobo_min_system\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ../: main.c dcm.c mpu6050.c
  group stm32_min_system
    C:/stm32/ustrobo_min_system/src/: approx_math.c battery.c button.c debug.c delay.c lcd_red.c lm629.c system.c ticks.c uart.c xbc_mb.c
  group stm32f10x_std
    C:/stm32/stm32f10x_std/src/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c system_stm32f10x.c stm32f10x_i2c.c
  group stm32f10x_startup
    C:/stm32/stm32f10x_std/: startup_stm32f10x_hd.s
